DEPENDS:remove = "coreutils"
